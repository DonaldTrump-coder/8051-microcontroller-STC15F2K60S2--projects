# Keil uVision project 16375401.uvproj, settings and files
target 16375401 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 16375401 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group Driver
    ../Driver/: Seg.c Seg.h Key.c Key.h LED.c LED.h iic.c onewire.c onewire.h iic.h Relay.c Relay.h init.c init.h superwave.c superwave.h
  group User
    ./: main.c
