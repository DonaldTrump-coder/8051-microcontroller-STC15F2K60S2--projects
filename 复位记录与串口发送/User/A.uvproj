# Keil uVision project A.uvproj, settings and files
target A (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: A +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group Driver
    ../Driver/: Key.c Key.h iic.c iic.h init.c init.h Uart.c Uart.h
  group User
    ./: main.c
